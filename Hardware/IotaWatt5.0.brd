# Repository CarbixEnergy/Carbix-Energy-Monitor

File readme.rst:

=========================================
Carbix Energy Monitor Project
=========================================

This is an open-source, open hardware project for monitoring energy,
forked from `IotaWatt <https://github.com/boblemaire/IoTaWatt>`_.
**We are committed to continuously optimizing supply chain costs to provide affordable hardware devices
and promote updates for this project.**

It can use any of dozens of common current transformers and will report the data locally via an integrated web server,
or upload to any of several third-party energy websites/databases.
Configuration and administration are through an easy-to-use browser-based utility running on a computer,
tablet, or smartphone.

CarbixEnergyMonitor is a full-function standalone energy monitor with the capability to store and
serve up to 15 years (or more) of comprehensive usage data and has an integrated web server with visualization apps.
At the same time, it can upload data to any of several (and counting) web-based databases and reporting systems.

Hardware is open and uses an ESP8266 nodeMCU, MCP3208 12-bit ADCs, an RTC, and an 8G SD card.

Metrics accumulated to 5-second resolution are Voltage(V), Power(Watts), Energy(kWh), VA, and PF.
While not certified to a standard, users typically report accuracy within 1% of their revenue meters.

Taking advantage of China's cost-effective supply chain, we will provide more reliable,
lower-priced energy monitors to quickly promote project development.
Now We sell Carbix energy monitor kit and current sensor accessories on `Amazon US <https://www.amazon.com/Monitor-CIRCUIT-Electricity-Open-Source-Open-Hardware/dp/B0CTCNH859/ref=sr_1_1?crid=GHFCVGY5C1JV&dib=eyJ2IjoiMSJ9.Ju6gpyxUTNqL_qv9ykezx-e1awh7hbRZ9p8xD7_apEs.Vw6jGimIhNebO4rCuWbQiBown-h-u4_xEG2iEEbBttw&dib_tag=se&keywords=carbix+energy+monitor&qid=1710125321&sprefix=carbix+energy+monito%2Caps%2C1449&sr=8-1>`_,
allowing users to purchase according to their needs. For this equipment,
there is still a lot of room for cost optimization, which requires us to have a certain scale effect,
and we will work hard for this.

.. image:: Docs/pics/amazon.png
    :scale: 20 %
    :align: center

Thanks to Bob Lemaire the founder of IotaWatt for doing such a great job, we will continue to promote the open source development of this project.

`Documentation <https://carbix-energy-monitor.readthedocs.io/en/latest/>`_

.. image:: Docs/pics/status/inputsOutputsDisplay.png
    :scale: 20 %
    :align: left

.. image:: Docs/pics/graphMultichannel.jpg
    :scale: 20 %
    :align: right

.. image:: Docs/pics/outputs/totalPowerOutput.png
    :scale: 20 %
    :align: center

.. image:: Docs/pics/PVoutput/PVoutputDisplay.png
    :scale: 20 %
    :align: center

.. image:: Docs/pics/influxDBGrafana.png
    :scale: 20 %
    :align: center

## EAGLE design Hardware/IotaWatt5.0.brd

Parts:
C1, C2: 10uf; C0805
C3, C4, C5, C6: .1uf; C0805
C7: 10uF; C0805
J0, J15, J16: 2.1MMJACKSMT; DCJACK_2MM_SMT
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14: STEREO_SMD; STEREO_SMT
J$20: MICROSD_PUSH/PULL; MICROSD
R1, R2: 4.7K; R0805
R3, R5, R7, R29, R31: 1K; R0805
R4: 220; R0805
R6, R9, R32: 12K; R0805
R8, R12, R16, R20, R24, R28, R36, R40, R44, R48, R52, R56, R57, R58: 20; R0805
R10, R11: None; R0805
U$1, U$2: MCP3208; SOIC_16
U$3: VREF_SHUNT; SOT23_3
U$4: PCF8523_RTC; SOIC_8
U$5: HEADER_1X4
U$16: NODEMCU
U$17, U$19, U$20, U$21: TVS_4CHAN_ARRAYSC-74; SC-74
U$18: CR1220SMD
U$22: LM358_DUAL_OP-AMP; SOIC_8
U$23: LED_RT_TRH; LED_TH_RT
Y1: 32Khz; CRYSTAL_8X3.8

Connections:
2V5: R29.2, U$1.1 (CH0), U$3.1 (V+)
3V3: C4.1, C5.1, C6.1, J$20.P$4 (VDD), R1.2, R3.2, R29.1, U$1.15 (AREF), U$1.16 (VDD), U$2.15 (AREF), U$2.16 (VDD), U$5.1, U$16.P$11 (3V11), U$16.P$16 (3V16), U$16.P$25 (3V25), U$17.P$5 (5), U$19.P$5 (5), U$20.P$5 (5), U$21.P$5 (5), U$22.8
ACBIAS: C2.2, J0.GND (RING), R31.2, U$22.6, U$22.7
ADC1: J8.P$2 (2), R8.2, U$1.2 (CH1), U$17.P$3 (3)
ADC2: J9.P$2 (2), R12.2, U$1.3 (CH2), U$17.P$4 (4)
ADC3: J10.P$2 (2), R16.2, U$1.4 (CH3), U$17.P$6 (6)
ADC4: J11.P$2 (2), R20.2, U$1.5 (CH4), U$19.P$1 (1)
ADC5: J12.P$2 (2), R24.2, U$1.6 (CH5), U$19.P$3 (3)
ADC6: J13.P$2 (2), R28.2, U$1.7 (CH6), U$19.P$4 (4)
ADC7: J14.P$2 (2), R36.2, U$1.8 (CH7), U$19.P$6 (6)
ADC10: R31.1, R32.1, U$2.1 (CH0), U$20.P$1 (1)
ADC11: J1.P$2 (2), R58.2, U$2.2 (CH1), U$20.P$3 (3)
ADC12: J2.P$2 (2), R57.2, U$2.3 (CH2), U$20.P$4 (4)
ADC13: J3.P$2 (2), R56.2, U$2.4 (CH3), U$20.P$6 (6)
ADC14: J4.P$2 (2), R52.2, U$2.5 (CH4), U$21.P$1 (1)
ADC15: J5.P$2 (2), R48.2, U$2.6 (CH5), U$21.P$3 (3)
ADC16: J6.P$2 (2), R44.2, U$2.7 (CH6), U$21.P$4 (4)
ADC17: J7.P$2 (2), R40.2, U$2.8 (CH7), U$21.P$6 (6)
ADCCS0: U$1.10 (CS), U$16.P$26 (GPIO2)
ADCCS1: U$2.10 (CS), U$16.P$27 (GPIO0), U$23.P$1
BIAS: C1.2, J1.P$1 (1), J1.P$4 (4), J2.P$1 (1), J2.P$4 (4), J3.P$1 (1), J3.P$4 (4), J4.P$1 (1), J4.P$4 (4), J5.P$1 (1), J5.P$4 (4), J6.P$1 (1), J6.P$4 (4), J7.P$1 (1), J7.P$4 (4), J8.P$1 (1), J8.P$4 (4), J9.P$1 (1), J9.P$4 (4), J10.P$1 (1), J10.P$4 (4), J11.P$1 (1), J11.P$4 (4), J12.P$1 (1), J12.P$4 (4), J15.GND (RING), J16.GND (RING), R5.2, R7.2, R8.1, R10.1, R11.1, R12.1, R16.1, R20.1, R24.1, R40.1, R44.1, R48.1, R52.1, R56.1, R57.1, R58.1, U$22.1, U$22.2
CSSD: J$20.P$2 (CS), U$16.P$20 (D8)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, J$20.P$6 (GND), R2.1, U$1.9 (DGND), U$1.14 (AGND), U$2.9 (DGND), U$2.14 (AGND), U$3.2 (V-), U$4.4 (GND), U$5.4, U$16.P$2 (GND), U$16.P$10 (G10), U$16.P$14 (G14), U$16.P$17 (G17), U$16.P$24 (G24), U$17.P$2 (2), U$18.P- (P$-), U$19.P$2 (2), U$20.P$2 (2), U$21.P$2 (2), U$22.4
MISO: J$20.P$7 (MISO), U$1.12 (DOUT), U$2.12 (DOUT), U$16.P$22 (MISO)
MOSI: J$20.P$3 (MOSI), U$1.11 (DIN), U$2.11 (DIN), U$16.P$21 (MOSI)
unnamed: C7.1, R3.1, U$4.8 (VDD)
unnamed: J15.PWR2 (TIP), R6.2
unnamed: J16.PWR2 (TIP), R9.2
unnamed: J14.P$1 (1), J16.GNDBREAK (RING_SW), R10.2, R36.1
unnamed: J13.P$1 (1), J15.GNDBREAK (RING_SW), R11.2, R28.1
unnamed: J14.P$4 (4), R7.1, R9.1
unnamed: R4.1, U$23.P$2
unnamed: J13.P$4 (4), R5.1, R6.1
unnamed: R4.2, U$16.P$30 (GPIO16)
unnamed: J0.PWR2 (TIP), R32.2
unnamed: U$4.3 (VBAT), U$18.P+ (P$+)
unnamed: U$4.2 (OSCO), Y1.P$4 (2)
unnamed: U$4.1 (OSCI), Y1.P$1 (1)
SCL: U$4.6 (SCL), U$5.3, U$16.P$29 (GPIO5)
SCLK: J$20.P$5 (CLK), U$1.13 (CLK), U$2.13 (CLK), U$16.P$23 (CLK)
SDA: U$4.5 (SDA), U$5.2, U$16.P$28 (GPIO4)
VREF: C3.2, R1.1, R2.2, U$22.3, U$22.5

Notes on the sheet:
CarbixEnergyMonitor Electric Power Monitor Version 5.0 February 10, 2019
alternate location
LM358
(c)Copyright 2019, CarbixEnergyMonitor, Inc. CarbixEnergyMonitor is a trademark of CarbixEnergyMonitor, Inc. This work is licensed under the Creative Commons 4.0 International Public License. https://creativecommons.org/licenses/by/4.0/legalcode Reference designs are provided "as is" with "all faul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

Board: 2 copper layers, 80.0 x 118.0 mm, 66 parts (0 on the bottom side), 42 nets.

## EAGLE design Hardware/VT_adapter.brd

Board: 2 copper layers, 40.0 x 163.0 mm, 40 parts (0 on the bottom side), 32 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 10uf; C1206
R1, R2, R6, R7, R9, R12, R13, R16: 12K; R1206
R3, R4, R5, R8, R10, R11, R14, R15: 1K; R1206
U$1, U$2, U$5, U$6, U$9, U$10, U$13, U$14: 2.1MMJACKSMT; DCJACK_2MM_SMT
U$3, U$4, U$7, U$8, U$11, U$12, U$15, U$16: STEREO_SMD; STEREO_SMT

Connections:
unnamed: C1.2, R3.2, U$3.P$1
unnamed: R1.2, R3.1, U$3.P$2
unnamed: C1.1, U$1.GND
unnamed: C2.1, U$2.GND
unnamed: R4.2, R6.2, U$8.P$2
unnamed: R1.1, U$1.PWR2
unnamed: R9.1, U$2.PWR2
unnamed: C4.2, R4.1, U$8.P$1
unnamed: C3.2, R5.2, U$7.P$1
unnamed: C3.1, U$5.GND
unnamed: R9.2, R11.2, U$4.P$2
unnamed: C2.2, R11.1, U$4.P$1
unnamed: R2.1, U$5.PWR2
unnamed: C4.1, U$6.GND
unnamed: R6.1, U$6.PWR2
unnamed: R2.2, R5.1, U$7.P$2
unnamed: R8.2, R12.2, U$12.P$2
unnamed: C6.2, R8.1, U$12.P$1
unnamed: C5.2, R10.2, U$11.P$1
unnamed: C5.1, U$9.GND
unnamed: R7.1, U$9.PWR2
unnamed: C6.1, U$10.GND
unnamed: R12.1, U$10.PWR2
unnamed: R7.2, R10.1, U$11.P$2
unnamed: R14.2, R16.2, U$16.P$2
unnamed: C8.2, R14.1, U$16.P$1
unnamed: C7.2, R15.2, U$15.P$1
unnamed: C7.1, U$13.GND
unnamed: R13.1, U$13.PWR2
unnamed: C8.1, U$14.GND
unnamed: R16.1, U$14.PWR2
unnamed: R13.2, R15.1, U$15.P$2

## Commit log

2024-01-18 Fork from IoTaWatt project
2024-01-18 Change the document name.
2024-01-25 Change the URL for the document.
2024-01-31 Change the config files.
2024-02-01 Modify firmware config name in updater
2024-02-01 Change config file.
2024-02-02 Change ed25519 public key
2024-02-04 Modify the name of firmware to install which will cause dump.
2024-03-11 Add amazon buyer link and pic

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
